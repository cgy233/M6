# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: RT_USING_DLIBC; __RTTHREAD__
  ICCARM.CCIncludePath2: libraries\HAL_Driver\Inc; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; applications; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; .; ..\..\..\libcpu\arm\cortex-m33; libraries\Device; ..\..\..\components\finsh; libraries\CMSIS; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; drivers; ..\..\..\components\libc\compilers\common\extension
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_GPIO.c HAL_EFlash.c
    libraries/Device/: Startup_ACM32F4_iar.s System_ACM32F4.c
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_remove.c syscall_close.c syscalls.c syscall_read.c syscall_mem.c syscall_write.c environ.c syscall_lseek.c syscall_open.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S syscall_iar.S cpuport.c trustzone.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringblk_buf.c dataqueue.c completion.c ringbuffer.c waitqueue.c workqueue.c pipe.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_uart.c board.c drv_gpio.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: thread.c device.c mempool.c scheduler.c timer.c irq.c idle.c components.c clock.c ipc.c object.c kservice.c mem.c
