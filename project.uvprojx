# Keil uVision project project.uvprojx, settings and files
target ACM32F4XX (6180000::V6.18::ARMCLANG)
  device: ACM32F403KCU7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ACM32F4 +hex
  AfterMake: fromelf.exe --bin --output ./build/ACM32F4.bin ./build/ACM32F4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;.\Peripherals\Power;.\Peripherals\RFID
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_GPIO.c HAL_EFlash.c
    libraries/Device/: Startup_ACM32F4.s System_ACM32F4.c
  group Applications
    applications/: main.c
    ./applications/: delay.c delay.h
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_uart.c drv_gpio.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Peripherals\RFID
    ./Peripherals/RFID/: nfc_iic.c nfc_iic.h SI523_App.c SI523_App.h exti.c exti.h
  group Peripherals\Power
    ./Peripherals/Power/: HAL_RTC.c power.c power.h
  group Peripherals\Touch
    ./Peripherals/Touch/: led.c led.h Si14tch.c Si14tch.h tk_exti.c tk_exti.h touch.c touch.h
