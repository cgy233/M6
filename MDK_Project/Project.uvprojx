# Keil uVision project Project.uvprojx, settings and files
target Project (6180000::V6.18::ARMCLANG)
  device: ACM32F403CET7 Aisinochip
  pack: Aisinochip.ACM32F4.1.0.2
  cpu: IRAM(0x20000000,0x30000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin --output ./Out_Files/Project.bin ./Objects/Project.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\Device\other;..\Core_Drivers\HAL_Driver;..\Core_Drivers\HAL_Driver\Src;..\Core_Drivers\HAL_Driver\Inc;..\Source_Code\APP;..\Source_Code\BSP_Driver;..\Source_Code\IC_Driver;..\..\..\Core_Drivers\CMSIS;..\..\..\Core_Drivers\Device;..\..\..\Core_Drivers\HAL_Driver\Inc;..\Source_Code\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group CoreDriver/CMSIS
    ../../../Core_Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../../../Core_Drivers/Device/: ACM32FP.h Startup_ACM32FP.s System_ACM32FP.c System_ACM32FP.h System_Accelerate.lib
  group CoreDriver/HAL
    ../../../Core_Drivers/HAL_Driver/Src/: HAL_DMA.c HAL_GPIO.c HAL_EFlash.c HAL_EFlash_EX.lib HAL_UART.c
    ../Source_Code/: HAL_EXTI.c
  group SourceCode/APP
    ../Source_Code/APP/: APP.c
  group SourceCode/main
    ../Source_Code/: main.c SI523_App.c SI523_App.h exti.c exti.h nfc_iic.c nfc_iic.h Si14tch.c Si14tch.h led.h led.c
    ./: delay.c delay.h finger.c finger.h
